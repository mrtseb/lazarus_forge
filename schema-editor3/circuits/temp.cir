MrT sim-spice
R0 1 4 1e9
R2 4 0 500
R4 1 9 1e9
R5 9 0 500
R7 1 14 1
R8 14 0 500
V1 1 0 10V
.op
